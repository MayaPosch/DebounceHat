# Repository MayaPosch/DebounceHat

File README.md:

# Debounce HAT for Raspberry Pi #

The Debounce HAT provides six opto-isolated digital input channels and is compatible with Raspberry Pi single board computers (SBC) with a 0.1" 2x20 pin header.
The Debounce HAT is designed to protect the controller side from electrostatic discharge transients, returning currents through low voltage spark gaps and a dedicated chassis ground connection (PE).

All inputs can be driven with 3 to 24 V with arbitrary polarity. An on-board isolated 5 V DCDC converter provides an uncommitted supply of up to 400 mA for switches, active sensors or remote circuitry.
The Debounce HAT implements filtering to suppress fast sequences of level changes typically encountered when using mechanical switches to provide plausible logic inputs to the target.

**Further Information**

A project page for this board along with ordering information can be found on the [Nyantronics site](http://www.nyantronics.com/debounce_hat.php "Debounce HAT on Nyantronics site").

**Electrical Specifications:**

-  6 opto-isolated, uncommitted bipolar inputs (Lo: |Vin| < 1 V, Hi: 3 V < |Vin| < 24 V) with transient protection.
-  Isolated DCDC providing 5 V, 400 mA for sensors, switches and remote circuitry (functional isolation, 4 kV DC / 1 s).
-  Power terminal with two pairs of 8 A - rated contacts for easy 5 V supply daisychaining to additional devices.
-  Advanced input protection with -24 V reverse polarity and +24 V overvoltage capability (load disconnect at &gt;=6.0 V).
-  Low ideal diode voltage drop of &lt;200 mV at 3 A.
-  &gt;2.4 mm clearance between logic and isolated sides (applies when PE not connected).
-  Spark gaps between input pairs.
-  Spark gaps between input pins and PE.
-  Spark gaps between isolated power and PE.
-  Channel probe points marked on pin header for easy setup and debugging.
-  EEPROM address default 0x50 can be changed via solder jumpers to resolve collision with other HATs (Multi-HAT support).  

**Mechanical Specifications:**

- 3.5 mm pitch terminal block for power in / pass-through (ø 0.2-1.5 mm² / 24-16 AWG).
- 2.5 mm pitch terminal blocks for isolated power and signal (ø 0.2-1.0mm² / 22-16 AWG).
- PE connection via 4.8 mm spade connector and M3 mounting hole.
- Raspberry Pi-compatible mounting hole pattern for M2.5 and M3 polyamide stand-off bolts. 
- 16 to 18 mm PCB stacking height (with pre-soldered header, defined by 2x20 pin 0.1" header, other heights available when hand soldering the header).

**Typical Applications:**

-  Digital inputs with ESD protection.
-  Mechanical switch / interlock inputs.
-  Isolated sensor interface.

## GPIO ##

The six channels of the board are mapped to the following GPIO pins:

  1. BCM 23 (WiringPi 4)
  2. BCM 26 (WiringPi 25)
  3. BCM 6 (WiringPi 22)
  4. BCM 5 (WiringPi 21)
  5. BCM 22 (WiringPi 3)
  6. BCM 17 (WiringPi 0)

In the below graphic those pins are marked in yellow (DBH n):

These pins are marked as probe points on the silkscreen of the 2x20 pin header.

### Power Distribution ###

The Debounce HAT can be powered from the SBC side. In this case the power terminals are disconnected to avoid back-driving. 

When instead a 5V supply is connected to the Debounce HAT power input, the HAT provides advanced input protection, featuring load-disconnect overvoltage protection and low dropout ideal diode reverse polarity protection, making the 5V input and signal inputs +/- 24 V tolerant.

A target voltage of 2 to 5.5 V needs to be provided on pin 17 (typically 3.3 V supplied by the SBC).

With external 5V connected, additional hardware can be connected to the power terminal and draw up to 6 A.

The Debounce HAT provides an isolated source of 5 V for axuilliary circuitry (switches, sensors, other). The on-board DCDC converter is connected to the 5 V pins of the 2x20 pin header (pin 2, pin 4) and active in both above mentioned supply schemes.

### Inputs ###

The inputs are driven with an external voltage in the range of 3 to 24V. With mechanical switches, a circuit has to be formed with the on-board isolated 5 V output, or with an external power supply.

**[Note]** The Debounce HAT is not intended to be connected to mains-powered appliances. When a fault condition cannot be excluded in which any contact of the isolated side (signal inputs and isolated 5V) is live, a fuse must be placed between the HAT PE contact and the contact to ground.

### EEPROM Configuration ###

The EEPROM configuration is provided in the `eeprom_setting.txt` file, which can be processed with the `eepmake` tool, and flashed to the EEPROM with `eepflash`. Both tools can be found at [https://github.com/raspberrypi/hats/tree/master/eepromutils](https://github.com/raspberrypi/hats/tree/master/eepromutils "Raspberry Pi HATs Github"). The jumper (two pin header) allows for the EEPROM to be set to write-protected/write-enabled mode (WP, WE, respectively).

**[Note]** When not flashing the EEPROM, the EEPROM header should be set to Write-Protect (WP) mode by removing any electrical connection between the `|EEPROM|` pins on the two-pin header to prevent any accidental rewriting of the EEPROM's contents.

### Liability Disclaimer ###

This board design has passed preliminary testing and is provided as-is. No responsibilities for damage or harm caused by its use will be accepted.

## KiCad design debounce_shield.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C12, C13: 100nF; C_0603_1608Metric; Manufacturer_Part_Number GMK107B7104KAHT; Mouser Part Number 963-GMK107B7104KAHT
C8: 220pF/440VAC; RV_Disc_D12mm_W4.6mm_P7.5mm; Manufacturer_Part_Number C907U221KZYDAAWL20; Mouser Part Number 80-C907U221KZYDAWL20
C9: 10uF/25V; C_1206_3216Metric; Mouser Part Number 963-TMK316B7106KL-TD
C10: 100nF/50V; C_0603_1608Metric; Manufacturer_Part_Number GMK107B7104KAHT; Mouser Part Number 963-GMK107B7104KAHT
C11: 10uF/35V; C_1206_3216Metric; Mouser Part Number 963-GMK316AB7106KL
C14: 10uF/25V; C_1206_3216Metric; Manufacturer_Part_Number TMK316B7106KL-TD; Mouser Part Number 963-TMK316B7106KL-TD
D1, D2, D3, D4, D5, D6: D_TVS; D_SOD-123; Manufacturer_Part_Number ATV02W110B-HF; Mouser Part Number 750-ATV02W110B-HF
D7: D_TVS; D_SMB; Manufacturer_Part_Number P6SMB24CA; Mouser Part Number 576-P6SMB24CA
FB1, FB2: FB; L_0805_2012Metric; Manufacturer_Part_Number BLM21PG331SN1D; Mouser Part Number 81-BLM21P331SG
H1: MountingHole_Pad; MountingHole_3.5mm_Pad_Via
IC1, IC2, IC3, IC4, IC5, IC6: LTV-814; DIP-4_W7.62mm; Manufacturer_Part_Number LTV-814; Mouser Part Number 859-LTV-814
IC7: MAX16914AUB+; SOP50P490X110-10N; Manufacturer_Part_Number MAX16914AUB+; Mouser Part Number 700-MAX16914AUB+
J1, J3, J4: Conn_01x06; 1990041; Manufacturer_Part_Number 1990041; Mouser Part Number 651-1990041
J2: RPi_GPIO; Pin_Header_Straight_2x20; Manufacturer_Part_Number ESQ-120-24-T-D; Mouser Part Number 200-ESQ12024TD
J5: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical; Manufacturer_Part_Number HMTSW-102-07-T-S-180; Mouser Part Number 200-HMTSW10207TS180
J6: 1985218; Manufacturer_Part_Number 1985218; Mouser Part Number 651-1985218
J7: 1285; Manufacturer_Part_Number 1285; Mouser Part Number 534-1285
JP1, JP2, JP3: SJ3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
L1: RLS-126; RLS126; Manufacturer_Part_Number RLS-126; Mouser Part Number 919-RLS-126
OVP1: LED; LED_0805_2012Metric; Mouser Part Number 604-AP2012HD
PS1: RKZE-0505S/H; RKZE0512SHP; Manufacturer_Part_Number RKZE-0505S/H; Mouser Part Number 919-RKZE-0505S/H
PWR1: LED; LED_0805_2012Metric; Mouser Part Number 604-AP2012HD
Q1, Q2: DMP3028LFDE7; U-DFN2020-6; Manufacturer_Part_Number DMP3028LFDE-7; Mouser Part Number 621-DMP3028LFDE-7
R1, R2, R3, R8: 3.9k; R_0603_1608Metric; Manufacturer_Part_Number AC0603FR-133K9L; Mouser Part Number 603-AC0603FR-133K9L
R4: 1k; R_0603_1608Metric; Manufacturer_Part_Number CRCW06031K00FKEAC; Mouser Part Number 71-CRCW06031K00FKEAC
R5, R6, R7: 1k; R_0603_1608Metric; Mouser Part Number 71-CRCW06031K00FKEAC
R11, R12, R13, R14, R15, R16, R21, R22, R23, R24, R25, R26: 1k; R_1206_3216Metric_Pad1.42x1.75mm_HandSolder; Mouser Part Number 71-CRCW12061K20JNEB
RN12, RN34, RN56: R_Pack04; R_Array_Convex_4x0603; Manufacturer_Part_Number YC164-JR-0747KL; Mouser Part Number 603-YC164-JR-0747KL
U1: 74LV14D; SOIC-14_3.9x8.7mm_P1.27mm; Mouser Part Number 771-74LV14D-T
U2: CAT24C32; SOIC-8_3.9x4.9mm_P1.27mm; Mouser Part Number 698-CAT24C32WI-GT3

Connections:
+3.3V: C12.1, C13.2, J2.17 (3.3V), JP1.3, JP2.3, JP3.3, R2.1, R3.1, R4.1, RN12.6 (R3.2), RN12.7 (R2.2), RN34.6 (R3.2), RN34.7 (R2.2), RN56.6 (R3.2), RN56.7 (R2.2), U1.14 (VDD), U2.8 (VCC)
+5V: C9.2, IC7.9 (SENSE_OUT), J2.2 (5V), J2.4 (5V), L1.1, Q2.1 (D), Q2.2 (D), Q2.5 (D), Q2.6 (D), Q2.8 (D)
/+5V_in: C7.1, D7.1 (A1), IC7.3 (SENSE_IN), J6.3, J6.4, Q1.1 (D), Q1.2 (D), Q1.5 (D), Q1.6 (D), Q1.8 (D)
A0: JP1.2, U2.1 (A0)
A1: JP2.2, U2.2 (A1)
A2: JP3.2, U2.3 (A2)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.2, C9.1, C11.2, C12.2, C13.1, D7.2 (A2), IC1.3, IC2.3, IC3.3, IC4.3, IC5.3, IC6.3, IC7.6 (GND), J2.6 (GND), J2.9 (GND), J2.14 (GND), J2.20 (GND), J2.25 (GND), J2.30 (GND), J2.34 (GND), J2.39 (GND), J5.1, J6.1, J6.2, JP1.1, JP2.1, JP3.1, PS1.2 (-VIN), R7.1, U1.7 (VSS), U2.4 (GND)
IDSCL: J2.28 (BCM1_ID_SC), R3.2, U2.6 (SCL)
IDSDA: J2.27 (BCM0_ID_SD), R2.2, U2.5 (SDA)
unnamed: C1.2, RN12.8 (R1.2), U1.5 (In)
unnamed: C2.2, RN12.5 (R4.2), U1.9 (In)
unnamed: C3.2, RN34.8 (R1.2), U1.11 (In)
unnamed: C4.2, RN34.5 (R4.2), U1.3 (In)
unnamed: C5.2, RN56.8 (R1.2), U1.13 (In)
unnamed: C6.2, RN56.5 (R4.2), U1.1 (In)
unnamed: C10.1, FB2.1, PS1.7 (+VOUT)
unnamed: C10.2, FB1.1, PS1.5 (-VOUT)
unnamed: C11.1, IC7.1 (VCC), IC7.4 (~SHDN), OVP1.2 (A), Q1.4 (S), Q1.7 (S), Q2.4 (S), Q2.7 (S)
unnamed: C14.1, FB2.2, J1.1, J1.2, J1.3, PWR1.2 (A)
unnamed: C8.1, C14.2, FB1.2, J1.4, J1.5, J1.6, R5.2
unnamed: D1.1 (A1), J4.1, R21.2
unnamed: D1.2 (A2), IC1.2, R11.1
unnamed: D2.1 (A1), J4.3, R22.2
unnamed: D2.2 (A2), IC2.2, R12.1
unnamed: D3.1 (A1), J4.5, R23.2
unnamed: D3.2 (A2), IC3.2, R13.1
unnamed: D4.1 (A1), J3.1, R24.2
unnamed: D4.2 (A2), IC4.2, R14.1
unnamed: D5.1 (A1), J3.3, R25.2
unnamed: D5.2 (A2), IC5.2, R15.1
unnamed: D6.1 (A1), J3.5, R26.2
unnamed: D6.2 (A2), IC6.2, R16.1
unnamed: IC1.1, R21.1
unnamed: IC1.4, RN12.1 (R1.1), RN12.2 (R2.1)
unnamed: IC2.1, R22.1
unnamed: IC2.4, RN12.3 (R3.1), RN12.4 (R4.1)
unnamed: IC3.1, R23.1
unnamed: IC3.4, RN34.1 (R1.1), RN34.2 (R2.1)
unnamed: IC4.1, R24.1
unnamed: IC4.4, RN34.3 (R3.1), RN34.4 (R4.1)
unnamed: IC5.1, R25.1
unnamed: IC5.4, RN56.1 (R1.1), RN56.2 (R2.1)
unnamed: IC6.1, R26.1
unnamed: IC6.4, RN56.3 (R3.1), RN56.4 (R4.1)
unnamed: IC7.2 (GATE1), Q1.3 (G)
unnamed: IC7.5 (~OV), R8.2
unnamed: IC7.7 (SET), R1.1, R7.2
unnamed: IC7.8 (TERM), R1.2
unnamed: IC7.10 (GATE2), Q2.3 (G)
unnamed: J2.11 (BCM17), U1.2 (Out)
unnamed: J2.15 (BCM22), U1.12 (Out)
unnamed: J2.16 (BCM23), U1.6 (Out)
unnamed: J2.29 (BCM5), U1.4 (Out)
unnamed: J2.31 (BCM6), R6.1
unnamed: J2.37 (BCM26), U1.8 (Out)
unnamed: J3.2, R14.2
unnamed: J3.4, R15.2
unnamed: J3.6, R16.2
unnamed: J4.2, R11.2
unnamed: J4.4, R12.2
unnamed: J4.6, R13.2
unnamed: J5.2, R4.2, U2.7 (WP)
unnamed: L1.2, PS1.1 (+VIN)
unnamed: OVP1.1 (K), R8.1
unnamed: PWR1.1 (K), R5.1
unnamed: R6.2, U1.10 (Out)
PE: C8.2, H1.1, J7.1, J7.2

Notes on the sheet:
YC164-JR-0747KL

Board: 2 copper layers, 65.0 x 56.0 mm, 72 parts (3 on the bottom side), 67 nets.

## Commit log

2018-03-15 Initial commit.
2018-03-16 Add HAT EEPROM & 5V feed diode.
2018-03-16 Update documentation.
2018-03-19 Add ID_SC, ID_SD pull-up resistors.
2018-03-20 Clarify label for EEPROM WP pin header.
2018-03-20 Add eeproms_settings.txt file. Update readme.
2018-11-29 Add optocoupler & other improvements.
2018-11-29 Update board image.
2018-11-30 Added fiducials. Tweaked traces & silkscreen.
2018-11-30 Add BOM, update README.
2019-03-10 Update PCB schematic and layout to revision 1.1.
2019-03-10 Update v1.1 PCB layout. Update README.
2019-03-11 Update README.
2019-03-28 Generate v1.1 gerbers.
2019-04-12 Update README. Update BOM.
2019-06-19 Reduce WP header to two pins. Clean-up PCB layout. Re-add art.
2019-06-26 Update README. Add GPIO graphic.
2019-06-26 Reduce spark gaps by 30%. DRC fixes.
2019-10-22 Replace RFMM DC-DC with RKZE. Add EMC components.
2019-10-22 Update README with new screenshots.
2019-11-14 Add new library components.
2019-11-14 Update schematic & PCB with new terminal connectors.
2019-11-16 Complete field entry for BOM.
2019-11-18 Change 6-position terminal to fixed Phoenix Contact 1990041 footprint.
2019-12-25 Update to v1.2-beta PCB revision.
2019-12-25 Update EEPROM settings for higher ampere rating.
2019-12-28 Update the 74LV14D component.
2019-12-28 Add BOM with prices.
2019-12-29 Add additional silkscreen for isolation purposes.
2019-12-29 Add Mouser BOM.
2020-01-21 Tweak isolation slots in PCB.
2020-01-21 Update board images.
2020-01-21 Tweak isolation slots on PCB.
2020-01-26 Move the paws so they don't get cut off in production.
2020-01-26 Add Gerber files for testing.
2020-02-26 Update interactive BOM.
2020-03-08 Update README with current technical specs.
2020-03-25 Update to revision 1.3.
2020-03-25 Update README for v1.3.
2020-04-14 Add additional filtering and protection to DC-DC circuit.
2020-04-20 Increase mounting hole size to 3 mm ID.
2020-04-20 Add silkscreen markings to GPIO area to denote 2x5 pin blocks.
2020-04-20 Add solder jumpers for EEPROM, additional artwork.
2020-04-20 Update README. Add current renders.
2020-04-21 Small silkscreen tweak.
2020-04-21 Update board render.
2020-04-21 Add v1.3 BOM.
2020-04-21 Update v1.3 BOM.
2020-04-21 Fix crooked line.
2020-04-28 Add v1.3 gerbers.
2020-05-08 Change J2#3,5 hole size. Adjust creepage to 3+mm. Add F.silkS labels.
2020-05-08 Update v1.3 gerbers.
